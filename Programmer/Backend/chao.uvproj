# Keil uVision project chao.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: chao +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c serial.c init.h serial.h eeprom.h eeprom.c lcd.c lcd.h chao.c chao.h motor.c motor.h
